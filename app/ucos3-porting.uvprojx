# Keil uVision project ucos3-porting.uvprojx, settings and files
target ucos-porting (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucos3-porting +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT,GD32F30x_HD
  c include: ..\uC-OS3\Source;..\uC-OS3\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\uC-CPU;..\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\uC-LIB;..\uC-CFG;..\bsp\gd32f30x\Library\Firmware\CMSIS\GD\GD32F30x\Include;..\bsp\gd32f30x\Library\Firmware\GD32F30x_standard_peripheral\Include;..\bsp\gd32f30x;..\bsp\gd32f30x\Library\Firmware\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group UCOS_CORE
    ../uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS_CPU
    ../uC-CPU/: cpu_core.c
  group UCOS_PORT
    ../uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
    ../uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ../bsp/gd32f30x/: bsp.c
  group MCU_STARTUP
    ../bsp/gd32f30x/Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group MCU_LIBRARY
    ../bsp/gd32f30x/Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_dbg.c
    ../bsp/gd32f30x/Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group APP
    ./: main.c
